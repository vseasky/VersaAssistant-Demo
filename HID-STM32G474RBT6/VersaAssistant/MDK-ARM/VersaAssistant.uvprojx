# Keil uVision project VersaAssistant.uvprojx, settings and files
target VersaAssistant (6210000::V6.21::ARMCLANG)
  device: STM32G474RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.5.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: VersaAssistant +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../../Protocol;../../Protocol/crc;../../CherryUSB/core;../../CherryUSB/port/fsdev;../../CherryUSB/common;../../CherryUSB/class/cdc;../../CherryUSB/class/hid;../../USBConfig;../Peripheral
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g474xx.s
  group Application/User/Core
    ../Core/Src/: main.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group CherryUSB
    ../../CherryUSB/core/: usbd_core.c
    ../../CherryUSB/class/cdc/: usbd_cdc.c
    ../../CherryUSB/port/fsdev/: usb_dc_fsdev.c
    ../../CherryUSB/class/hid/: usbd_hid.c
  group Peripheral
    ../Peripheral/: bsp_versaassistant.c bsp_systick.c bsp_uart.c bsp_key.c
  group Protocol
    ../../Protocol/crc/: bsp_crc8.c bsp_crc16.c
    ../../Protocol/: bsp_protocol.c
  group USBConfig
    ../../USBConfig/: usb_config.c
software components: CMSIS:CORE 5.6.0
